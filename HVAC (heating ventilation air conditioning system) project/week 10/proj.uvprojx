# Keil uVision project proj.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proj
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: D:\TivaWare\inc;D:\TivaWare\driverlib
  asm include: D:\TivaWare\driverlib\rvmdk
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c tm4c123gh6pm.h UART.c UART.h ADC.c ADC.h Keypad.h LCD.h relay.c relay.h
    D:/TivaWare/driverlib/rvmdk/: driverlib.lib
    ../../../../Desktop/: LCD.c Keypad.c
software components: RTOS:Config 10.4.6, RTOS:Core 10.4.6, RTOS:Heap 10.4.6, RTOS:Timers 10.4.6, CMSIS:CORE 5.5.0, Device:Startup 1.0.1
